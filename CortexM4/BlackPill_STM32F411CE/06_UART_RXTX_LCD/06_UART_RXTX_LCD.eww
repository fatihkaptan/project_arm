<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\06_UART_RXTX_LCD.ewp</path>
    </project>
    <batchBuild />
</workspace>
