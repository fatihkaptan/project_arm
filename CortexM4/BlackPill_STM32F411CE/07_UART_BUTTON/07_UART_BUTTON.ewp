# IAR project 07_UART_BUTTON.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: $PROJ_DIR$; Core_BlackPill; Periph_BlackPill; Periph_BlackPill\inc; Periph_BlackPill\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 04_LCD_NEW.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c
  group App/inc
    ./: button.h io.h lcd.h system.h UART.h
  group App/src
    ./: button.c io.c lcd.c system.c UART.c
  group Core
    Core_BlackPill/: delay.s startup_stm32f411xe.s stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group Periph
    Periph_BlackPill/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c
    Periph_BlackPill/inc/: stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_usart.h
