<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\04_LCD_NEW.ewp</path>
    </project>
    <batchBuild />
</workspace>
