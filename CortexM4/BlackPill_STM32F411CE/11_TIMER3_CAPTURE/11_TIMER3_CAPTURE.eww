<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\11_TIMER3_CAPTURE.ewp</path>
    </project>
    <batchBuild />
</workspace>
