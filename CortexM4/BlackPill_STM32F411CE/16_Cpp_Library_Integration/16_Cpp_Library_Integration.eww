<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\16_Cpp_Library_Integration.ewp</path>
    </project>
    <batchBuild />
</workspace>
