<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\15_Sensor_ADC_wTIM.ewp</path>
    </project>
    <batchBuild />
</workspace>
