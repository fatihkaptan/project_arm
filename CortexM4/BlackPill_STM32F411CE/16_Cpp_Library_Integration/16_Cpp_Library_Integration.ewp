# IAR project 16_Cpp_Library_Integration.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F411xE
  ICCARM.CCIncludePath2: $PROJ_DIR$; Core_BlackPill; Periph_BlackPill; Periph_BlackPill\inc; Periph_BlackPill\src; Drivers\SysView_RTT\SEGGER
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: 04_LCD_NEW.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c main.h
  group App/inc
    ./: adc.h io.h oled.h spi.h system.h timer.h
    Cpp_Library_Project/: led_task_cpp.h
  group App/src
    ./: adc.c io.c oled.c spi.c system.c timer.c
  group Core
    Core_BlackPill/: delay.s startup_stm32f411xe.s stm32f4xx.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c system_stm32f4xx.h
  group Drivers/Segger/inc
    Drivers/SysView_RTT/SEGGER/: Global.h SEGGER.h SEGGER_RTT.h SEGGER_RTT_Conf.h SEGGER_SYSVIEW.h SEGGER_SYSVIEW_Conf.h SEGGER_SYSVIEW_ConfDefaults.h SEGGER_SYSVIEW_Int.h
  group Drivers/Segger/src
    Drivers/SysView_RTT/SEGGER/: SEGGER_RTT.c SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c SEGGER_SYSVIEW.c SEGGER_SYSVIEW_Conf._NoOS.c
  group Periph
    Periph_BlackPill/src/: stm32f4xx_adc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_tim.c
    Periph_BlackPill/inc/: stm32f4xx_adc.h stm32f4xx_gpio.h stm32f4xx_rcc.h stm32f4xx_spi.h
  group UserLibs
    Cpp_Library_Project/Debug/Exe/: Cpp_Lib_Project.a
